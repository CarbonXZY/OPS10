# Keil uVision project OPS10.uvprojx, settings and files
target OPS10 (6240000::V6.24::ARMCLANG)
  device: STM32H503RBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: OPS10 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx,ARM_MATH_ARMV8MML,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../User_alg;../User_dvc;../User_drv;../User_ita;../User_tsk;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Include/dsp;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fdcan.c i2c.c icache.c memorymap.c spi.c tim.c usb.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group User_drv
    ../User_drv/: drv_can.cpp drv_can.h drv_math.cpp drv_math.h drv_spi.cpp drv_spi.h drv_tim.cpp drv_tim.h
  group User_dvc
    ../User_dvc/: drv_MCC5983.cpp drv_MCC5983.h dvc_BMP388.cpp dvc_BMP388.h dvc_ICM42688.cpp dvc_ICM42688.h dvc_ICM42688_reg.h dvc_MT6816.cpp dvc_MT6816.h dvc_dwt.cpp dvc_dwt.h
  group User_alg
    ../User_alg/: alg_fsm.cpp alg_fsm.h
  group User_ita
    ../User_ita/: ita_chaiot.cpp ita_chaiot.h
  group User_tsk
    ../User_tsk/: tsk_config_and_callback.cpp tsk_config_and_callback.h
  group Middleware
    ../Middlewares/ST/ARM/DSP/Lib/: arm_ARMv8MMLlfsp_math.lib
software components: CMSIS:CORE 6.2.0
